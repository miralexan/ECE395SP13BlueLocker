# Keil uVision project bluelock.uvproj, settings and files
target bluelock (ARM-ADS)
  device: LPC1114/202 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: bluelock
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./: startup_LPC11xx.s
    C:/Keil/ARM/Startup/NXP/LPC11xx/: system_LPC11xx.c
  group bluelock
    ./: main.c bluelock.h
  group Interface
    ./: debug.h gpio.h uart.h uart.c spio.c spio.h storage.c storage.h hasher.c hasher.h password.c password.h device.h device.c
  group SHA
    ./: sha.c sha1.c sha1.h
